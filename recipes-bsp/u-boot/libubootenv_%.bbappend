FILESEXTRAPATHS:prepend:imx6sx-slx-som := "${THISDIR}/files:"
